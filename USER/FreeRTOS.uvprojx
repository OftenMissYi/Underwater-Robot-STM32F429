# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\PCF8574;..\HARDWARE\MYIIC;..\HARDWARE\RS485;..\COMMUNICATE;..\HARDWARE\timer;..\HARDWARE\Light;..\HARDWARE\Thruster;..\CONTROL\Control;..\CONTROL\Sensors;..\HARDWARE\JY901;..\SYSTEM\usart6;..\HARDWARE\HWT905;..\CONTROL\pid;..\CONTROL\attitude_pid;..\HARDWARE\MS5837;..\HARDWARE\rs232;..\HARDWARE\DHT22;..\CONTROL\velocity_pid;..\HARDWARE\DS300;..\HARDWARE\flash;..\CONTROL\pid_flash;..\CONTROL\Sensor_filter;..\HARDWARE\IIC1;..\HARDWARE\BMP280;..\HARDWARE\my_dsp;..\HARDWARE\timer12;..\CONTROL\depth_pid;..\AUTO;..\AUTO;..\CONTROL\servo;..\HARDWARE\timer9;..\HARDWARE\timer3;..\HARDWARE\depth_iic;..\HARDWARE\bmp_iic
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart6/: usart6.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/MS5837/: MS5837.c
    ../HARDWARE/Light/: light.c
    ../HARDWARE/Thruster/: thruster.c
    ../HARDWARE/HWT905/: HWT905.c
    ../HARDWARE/rs232/: rs232.c
    ../HARDWARE/DHT22/: dht22.c
    ../HARDWARE/DS300/: ds300.c
    ../HARDWARE/flash/: flash.c
    ../HARDWARE/BMP280/: bmp280.c
    ../HARDWARE/my_dsp/: my_dsp.c
    ../HARDWARE/timer12/: timer12.c
    ../HARDWARE/timer9/: timer9.c
    ../HARDWARE/timer3/: timer3.c
    ../HARDWARE/depth_iic/: depth_iic.c
    ../HARDWARE/bmp_iic/: bmp_iic.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group COMMUNICATE
    ../COMMUNICATE/: link232.c ibus.c
  group CONTROL
    ../CONTROL/Control/: control.c
    ../CONTROL/Sensors/: sensors.c
    ../CONTROL/pid/: pid.c
    ../CONTROL/attitude_pid/: attitude_pid.c
    ../CONTROL/velocity_pid/: velocity_pid.c
    ../CONTROL/pid_flash/: pid_flash_init.c
    ../CONTROL/Sensor_filter/: sensor_filter.c
    ../CONTROL/depth_pid/: depth_pid.c
    ../CONTROL/servo/: servo.c
  group README
    ../: readme.txt
  group AUTO
    ../AUTO/: auto_pid.c auto_control.c auto_need_state.c auto_remote.c
